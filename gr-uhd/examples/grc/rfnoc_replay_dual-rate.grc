options:
  parameters:
    author: Martin Anderseck <martin.anderseck@ni.com>
    copyright: (C) 2023 Ettus Research, a National Instruments Brand
    description: This example demonstrates the X440 Dual Rate feature for capturing the L-band
    generate_options: qt_gui
    id: x440_test
    output_language: python
    title: X440 Dual Rate Example
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: play_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,2,1,1]'
    label: Play Offset
    type: int
    value: '0'
  states: {}
- name: play_port
  id: variable_qtgui_chooser
  parameters:
    gui_hint: ':[2,2,1,1]'
    label: Play Port
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: play_size
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,3,1,1]'
    label: Play Size
    type: int
    value: '80000'
  states: {}
- name: record_offset
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,0,1,1]'
    label: Record Offset
    type: int
    value: '0'
  states: {}
- name: record_port
  id: variable_qtgui_chooser
  parameters:
    gui_hint: ':[2,1,1,1]'
    label: Record Port
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: record_size
  id: variable_qtgui_entry
  parameters:
    gui_hint: ':[3,1,1,1]'
    label: Record Size
    type: int
    value: '80000'
  states: {}
- name: samp_rate0
  id: variable
  parameters:
    value: 375e6
  states: {}
- name: samp_rate1
  id: variable
  parameters:
    value: 500e6
  states: {}
- name: stream_cmd_dict
  id: variable
  parameters:
    value: '{''stream_now'': True, ''stream_mode'': ''start_cont'' if stream_on else ''stop_cont''}'
  states: {}
- name: stream_on
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: |-
      All of this is simply to provide a toggle switch to turn loopback on and off.
      By default, the RFNoC RX Radio does not stream, it waits for a stream command.
      In this flow graph, we provide that stream command manually, through the
      command message port.
    initPressed: 'False'
    label: Enable Stream
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: uhd_rfnoc_graph_0
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"product=x440,addr=10.89.13.41"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: stream_cmd
    target: stream_cmd_dict
  states: {}
- name: cont_play_push_button
  id: uhd_msg_push_button
  parameters:
    command: play
    gui_hint: ':[1,2,1,1]'
    label: Play Continuous
    port: play_port
    repeat: 'True'
  states: {}
- name: fullness_push_button
  id: uhd_msg_push_button
  parameters:
    command: get_record_fullness
    gui_hint: ':[2,0,1,1]'
    label: Get Record Fullness
    port: record_port
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: play_push_button
  id: uhd_msg_push_button
  parameters:
    command: play
    gui_hint: ':[1,1,1,1]'
    label: Play
    port: play_port
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate0
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: record_push_button
  id: uhd_msg_push_button
  parameters:
    command: record
    gui_hint: ':[1,0,1,1]'
    label: Record
    port: record_port
  states: {}
- name: stop_push_button
  id: uhd_msg_push_button
  parameters:
    command: stop
    gui_hint: ':[1,3,1,1]'
    label: Stop Playback
    port: play_port
  states: {}
- name: uhd_rfnoc_replay_0
  id: uhd_rfnoc_replay
  parameters:
    play_offset0: '0'
    play_size0: play_size
    play_type0: sc16
    record_offset0: '0'
    record_size0: record_size
    record_type0: sc16
  states: {}
- name: uhd_rfnoc_replay_0_0
  id: uhd_rfnoc_replay
  parameters:
    play_offset0: '0'
    play_size0: '80000'
    record_offset0: '0'
    record_size0: '80000'
    record_type0: sc16
  states: {state: disabled}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: samp_rate0
    dc_offset0: 'False'
    frequency0: center_freq
    gain0: '0'
    instance_index: '0'
    iq_balance0: 'False'
    rate: samp_rate0
  states: {}
- name: uhd_rfnoc_rx_radio_1
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: samp_rate1
    dc_offset0: 'False'
    frequency0: center_freq
    gain0: '0'
    instance_index: '1'
    iq_balance0: 'False'
    rate: samp_rate1
  states: {state: disabled}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_rx_streamer_0_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {state: disabled}

connections:
- [blocks_var_to_msg_0, msgout, uhd_rfnoc_rx_radio_0, command]
- [blocks_var_to_msg_0, msgout, uhd_rfnoc_rx_radio_1, command]
- [cont_play_push_button, pressed, uhd_rfnoc_replay_0, command]
- [cont_play_push_button, pressed, uhd_rfnoc_replay_0_0, command]
- [fullness_push_button, pressed, uhd_rfnoc_replay_0, command]
- [fullness_push_button, pressed, uhd_rfnoc_replay_0_0, command]
- [play_push_button, pressed, uhd_rfnoc_replay_0, command]
- [play_push_button, pressed, uhd_rfnoc_replay_0_0, command]
- [record_push_button, pressed, uhd_rfnoc_replay_0, command]
- [record_push_button, pressed, uhd_rfnoc_replay_0_0, command]
- [stop_push_button, pressed, uhd_rfnoc_replay_0, command]
- [stop_push_button, pressed, uhd_rfnoc_replay_0_0, command]
- [uhd_rfnoc_replay_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_replay_0, debug_msgs, blocks_message_debug_0, print]
- [uhd_rfnoc_replay_0_0, '0', uhd_rfnoc_rx_streamer_0_0, '0']
- [uhd_rfnoc_replay_0_0, debug_msgs, blocks_message_debug_0_0, print]
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_replay_0, '0']
- [uhd_rfnoc_rx_radio_1, '0', uhd_rfnoc_replay_0_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-559-gbfa461dc
